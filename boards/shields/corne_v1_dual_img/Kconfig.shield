## boards/shields/corne_v1_dual_img/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_SHIELD_BASE
    def_bool $(shields_list_contains,corne_v1_dual_img)
```
